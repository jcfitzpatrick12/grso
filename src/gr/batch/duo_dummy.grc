options:
  parameters:
    generate_options: qt_gui
    id: rsp_duo_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq_0
  id: variable
  parameters:
    value: 95.8e6
  states: {}
- name: center_freq_1
  id: variable
  parameters:
    value: 396e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /home
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_file_meta_sink_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /home
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: 300e3
    biasT: 'False'
    center_freq: '0'
    center_freq0: center_freq_0
    center_freq1: center_freq_1
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '59'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_gR0: '0'
    rf_gR1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (independent RX)
    sample_rate: samp_rate
    sample_rate_non_single_tuner: 500e3
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [sdrplay3_rspduo_0, '0', blocks_file_meta_sink_0, '0']
- [sdrplay3_rspduo_0, '1', blocks_file_meta_sink_1, '0']

metadata:
  file_format: 1
