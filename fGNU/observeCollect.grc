options:
  parameters:
    generate_options: qt_gui
    id: observeCollect
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 95.8e6
  states: {}
- name: pseudo_start_time
  id: variable
  parameters:
    value: timeStamper.timeStamper().returnDatetimeNowString()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmtDictMaker.BuildDict().GetDict(samp_rate,center_freq,pseudo_start_time)
    file: timeStamper.timeStamper().returnFilePath(pseudo_start_time)
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e5
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pmtDictMaker
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import pmt

      class BuildDict:
      	def __init__(self):
      		self.pmt_dict = pmt.make_dict()

      	# Define a function to convert Python types to PMT types
      	def to_pmt(self,value):
      		if isinstance(value, int):
      			return pmt.from_long(value)
      		elif isinstance(value, float):
      			return pmt.from_double(value)
      		elif isinstance(value, str):
      			return pmt.intern(value)
      		elif isinstance(value, bool):
      			return pmt.from_bool(value)
      		# Add more type conversions here if needed
      		else:
      			raise ValueError(f"Unsupported type: {type(value)}")



      	def GetDict(self,samp_rate,center_freq,pseudo_start_time):
      		# Define a list of key-value pairs with different types
      		key_value_pairs = [
      		('samp_rate', int(samp_rate)),
      		('center_freq', float(center_freq)),
      		('pseudo_start_time', pseudo_start_time),
      		# Add more key-value pairs here
      		]
      		# Add key-value pairs to the PMT dictionary
      		for key, value in key_value_pairs:
      			pmt_key = pmt.intern(key)
      			pmt_value = self.to_pmt(value)
      			self.pmt_dict = pmt.dict_add(self.pmt_dict, pmt_key, pmt_value)
      		
      		return self.pmt_dict
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    int_min: '-160'
    type: complex
    update_time: '0.005'
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    agc_setpoint: '0'
    bandwidth: samp_rate
    center_freq: center_freq
    gain: '39'
    lna_state: '1'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: timeStamper
  id: epy_module
  parameters:
    source_code: |
      from datetime import datetime
      import os

      class timeStamper:

      	def returnDatetimeNowString(self):
      		return datetime.now().strftime("%Y-%m-%dT%H:%M:%S")
      		
      	def returnFilePath(self,appendDate):
      		dataPath = os.path.join(os.environ['GBOPARENTPATH'],"data",appendDate)
      		return dataPath
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_meta_sink_0_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_file_meta_sink_0_0, '0']
- [soapy_sdrplay_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
